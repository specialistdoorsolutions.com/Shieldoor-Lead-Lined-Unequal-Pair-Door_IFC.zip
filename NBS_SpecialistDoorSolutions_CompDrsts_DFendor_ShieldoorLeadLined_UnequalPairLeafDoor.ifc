Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-01-24T13:09:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Jan 24 13:09:29 2023* Host: BIMServices* Database: C:\Users\PIOTRB~1\AppData\Local\Temp\90e04317-eb41-43b6-9561-8e8934ec674e\4ad06e6b-096d-4b25-84b6-259da7a6cdf9\ifc* Database version: 5507* Database creation date: Tue Jan 24 13:09:29 2023* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Jan 24 13:09:29 2023* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Jan 24 13:09:29 2023* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcDoor: NBS_SpecialistDoorSolutions_CompDrsts_DFendor_ShieldoorLeadLined_UnequalPairLeafDoor:ShieldoorLeadLinedUnequalPairDoor, NBS_SpecialistDoorSolutions_CompDrsts_DFendor_ShieldoorLeadLined_UnequalPairLeafDoor:ShieldoorLeadLinedUnequalPairDoor:637731
In: Level 0
Type - OperationType: DOUBLE_DOOR_SINGLE_SWING; ConstructionType: WOOD; ParameterTakesPrecedence: no; Sizeable: no; Material: NBS_SpecialistDoorSolutions_StainlessSteel, NBS_SpecialistDoorSolutions_TexturedFinish_LupinLRV23, NBS_Glass_Single, NBS_SpecialistDoorSolutions_Priviglaze, NBS_SpecialistDoorSolutions_WarningLight_Red, NBS_ClearanceZone, NBS_SpecialistDoorSolutions_WarningLight_Yellow
Type - NBS_SpecialistDoorSolutions_CompDrsts_DFendor_ShieldoorLeadLined_UnequalPairLeafDoor:ShieldoorLeadLinedUnequalPairDoor:637731:1 - PanelOperation: SWINGING
Type - BOS_General - Author: NBS; BIMObjectName: NBS_SpecialistDoorSolutions_CompositeDoorsets_ShieldoorLeadLinedUnequalPairDoor; ManufacturerName: Specialist Door Solutions; ManufacturerURL: specialistdoorsolutions.com; NBSCertification: www.nationalbimlibrary.com/cert/jcvfunnb; ProductInformation: https://specialistdoorsolutions.com/products/doorsets/sds-dfendoor/; Uniclass2015Title: Composite doorsets; Uniclass2015Code: Pr_30_59_24_16; Uniclass2015Version: Products v1.22; Version: 1
Type - NBS_Data - AcousticPerformance: 0 - 35 dB; ArchitravesColour: American black, American white, Aqua, Ash, Buoyant, Buttermilk, Carbon, Chalk, Cherry, Claret, Cloud, Cobble, Cotton, Cyan, Denim, Ellmau beech, Flint, Grape, Grass, Gunpowder, Hessian, Ice, Jade, Lupin, Mandarin, Midnight, Mushroom, Neon, Night, Peppermint, Plum, Primrose, Pumpkin, Rose, Sage, Sky, Snowflake, Spearmint, Standard white, Steel, Swiss elm, Trojan oak, Verdure, Zephyr; ArchitravesFinish: PVC; ArchitravesMaterial: Lead-backed; BeadingType: Flush; ColourExternal: American black, American white, Aqua, Ash, Buoyant, Buttermilk, Carbon, Chalk, Cherry, Claret, Cloud, Cobble, Cotton, Cyan, Denim, Ellmau beech, Flint, Grape, Grass, Gunpowder, Hessian, Ice, Jade, Lupin, Mandarin, Midnight, Mushroom, Neon, Night, Peppermint, Plum, Primrose, Pumpkin, Rose, Sage, Sky, Snowflake, Spearmint, Standard white, Steel, Swiss elm, Trojan oak, Verdure, Zephyr; ColourInternal: American black, American white, Aqua, Ash, Buoyant, Buttermilk, Carbon, Chalk, Cherry, Claret, Cloud, Cobble, Cotton, Cyan, Denim, Ellmau beech, Flint, Grape, Grass, Gunpowder, Hessian, Ice, Jade, Lupin, Mandarin, Midnight, Mushroom, Neon, Night, Peppermint, Plum, Primrose, Pumpkin, Rose, Sage, Sky, Snowflake, Spearmint, Standard white, Steel, Swiss elm, Trojan oak, Verdure, Zephyr; Configuration: Leaf and part-leaf, single-action; ContainsRedListMaterials: Yes; CountryOfProductManufacture: United Kingdom; DoorAccessories: Not required, Edge protectors, Kick plates; DoorLeafCore: Laminated hardwood; DoorLeafFacingsExternal: PVC; DoorLeafFacingsInternal: PVC; DoorLeafPanelDetails: Lead-lined; DoorLeafThickness: 53 mm, 63 mm; FrameColour: American black, American white, Aqua, Ash, Buoyant, Buttermilk, Carbon, Chalk, Cherry, Claret, Cloud, Cobble, Cotton, Cyan, Denim, Ellmau beech, Flint, Grape, Grass, Gunpowder, Hessian, Ice, Jade, Lupin, Mandarin, Midnight, Mushroom, Neon, Night, Peppermint, Plum, Primrose, Pumpkin, Rose, Sage, Sky, Snowflake, Spearmint, Standard white, Steel, Swiss elm, Trojan oak, Verdure, Zephyr; FrameFilmThicknessMinimum: 1.5-2 mm; FrameFinish: PVC; FrameMaterials: Hardwood; FrameThreshold: 3-10 mm; FrameTypeOptions: Traditional frame; GlazingType: Priviglaze+, Priviglaze, Flush warning light, Clearglaze; ReactionToFire: NFR, FD30s, FD60s; Standard: To BS 476 Part 22:1987, BS EN 1634-1; StrengthAndDurability: Severe Duty; ThirdPartyCertification: BM Trada Q-Mark, FSC, ISO: 9001:2015, ISO 14001:2015
Type - IFC - IfcExportAs: IfcDoorType; IfcExportType: DOOR
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_24_16:Composite doorsets; CodePerformance: n/a; Color: Blue, White, Red, Brown, Purple, Orange, Yellow, Green, Grey, Beige, Black, Cream, Pink, Turquoise; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: PVC; Grade: n/a; Manufacturer: Russell@specialistdoorsolutions.com; Material: Lead, Wood, Glass, PVC, Timber, Steel; ModelNumber: n/a; ModelReference: ShieldoorLeadLinedUnequalPairDoor; Name: CompositeDoorsets_ShieldoorLeadLinedUnequalPairDoor_SpecialistDoorSolutions; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: Five year; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
OverallHeight: 2125 mm; OverallWidth: 1650 mm; Material: NBS_SpecialistDoorSolutions_Priviglaze, NBS_Glass_Single, NBS_SpecialistDoorSolutions_WarningLight_Yellow, NBS_SpecialistDoorSolutions_WarningLight_Red, NBS_SpecialistDoorSolutions_StainlessSteel, NBS_SpecialistDoorSolutions_TexturedFinish_LupinLRV23
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
